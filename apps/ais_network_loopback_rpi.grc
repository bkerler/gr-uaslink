<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ais_network_loop_rpi</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>uaslink_message_debug_hex</key>
<param><key>id</key><value>uaslink_message_debug_hex_0</value></param>
<param><key>description</key><value>16129</value></param>
</block>
<block>
<key>uaslink_message_debug_hex</key>
<param><key>id</key><value>uaslink_message_debug_hex_0_0</value></param>
<param><key>description</key><value>16128</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_sink_pp</key>
<param><key>id</key><value>uaslink_pymavlink_source_sink_pp_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'/dev/ttyAMA0'</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>'tcp://0.0.0.0:16129'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:6128'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_1</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:5056'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:6129'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>'tcp://192.168.10.1:16128'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_1</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:5057'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_1</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_message_debug_hex_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>uaslink_message_debug_hex_0_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_1</source_block_id><sink_block_id>uaslink_pymavlink_source_sink_pp_0</sink_block_id><source_key>out</source_key><sink_key>MAVLink_IN</sink_key></connection>
</flow_graph>
