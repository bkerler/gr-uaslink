<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>modem_iface</value></param>
<param><key>category</key><value>[uaslink]</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pdu_filter</key>
<param><key>id</key><value>blocks_pdu_filter_0</value></param>
<param><key>invert</key><value>False</value></param>
<param><key>k</key><value>pmt.intern("never_going_to_see_this_key")</value></param>
<param><key>v</key><value>pmt.intern("whatever")</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>data_rx_pdu_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>data_rx_pdu</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>data_tx_pdu_port</value></param>
<param><key>label</key><value>data_tx_pdu</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from PyQt4 import Qt</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>link_ctrl_in_port</value></param>
<param><key>label</key><value>link_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>link_ctrl_out_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>link_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>packet_modem</key>
<param><key>id</key><value>packet_modem_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>psk_burst_modem</key>
<param><key>id</key><value>psk_burst_modem_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>radio_ctrl_in_port</value></param>
<param><key>label</key><value>radio_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>radio_ctrl_out_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>radio_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rx_samples_port</value></param>
<param><key>label</key><value>rx_samples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>tx_samples_port</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>tx_samples</value></param>
</block>
<connection><source_block_id>blocks_pdu_filter_0</source_block_id><sink_block_id>radio_ctrl_out_port</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>data_tx_pdu_port</source_block_id><sink_block_id>packet_modem_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>data_tx_pdu_port</source_block_id><sink_block_id>psk_burst_modem_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>link_ctrl_in_port</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>link_ctrl_in_port</source_block_id><sink_block_id>link_ctrl_out_port</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>packet_modem_0</source_block_id><sink_block_id>data_rx_pdu_port</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>packet_modem_0</source_block_id><sink_block_id>tx_samples_port</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk_burst_modem_0</source_block_id><sink_block_id>data_rx_pdu_port</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>psk_burst_modem_0</source_block_id><sink_block_id>tx_samples_port</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_ctrl_in_port</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>radio_ctrl_in_port</source_block_id><sink_block_id>blocks_pdu_filter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>rx_samples_port</source_block_id><sink_block_id>packet_modem_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_samples_port</source_block_id><sink_block_id>psk_burst_modem_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
