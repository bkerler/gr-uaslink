<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radio_top_rpi</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfg</value></param>
<param><key>comment</key><value>A place to put values for various configurations.
Maybe better to use file variables.</value></param>
<param><key>value</key><value>{"base":{"freqs":[freqs[0],freqs[1]]},"remote":{"freqs":[freqs[1],freqs[0]]} }[config]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>[3.017e9,3.013e9]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>channel_tagged_uhd</key>
<param><key>id</key><value>channel_tagged_uhd_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rx_freq</key><value>cfg["freqs"][0]</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>cfg["freqs"][1]</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
</block>
<block>
<key>channel_uhd</key>
<param><key>id</key><value>channel_uhd_0</value></param>
<param><key>rx_freq</key><value>cfg["freqs"][0]</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>cfg["freqs"][1]</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>base</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>modem_iface</key>
<param><key>id</key><value>modem_iface_0</value></param>
<param><key>samp_rate</key><value>100e3</value></param>
</block>
<block>
<key>no_delay</key>
<param><key>id</key><value>no_delay_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>uaslink_binary_vector_to_pdu</key>
<param><key>id</key><value>uaslink_binary_vector_to_pdu_0</value></param>
</block>
<block>
<key>uaslink_pdu_to_binary_vector</key>
<param><key>id</key><value>uaslink_pdu_to_binary_vector_1</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_sink_pp</key>
<param><key>id</key><value>uaslink_pymavlink_source_sink_pp_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14001'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>channel_tagged_uhd_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_uhd_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>uaslink_binary_vector_to_pdu_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>Vector_IN</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>uaslink_pymavlink_source_sink_pp_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_tagged_uhd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_uhd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>no_delay_0</source_block_id><sink_block_id>uaslink_binary_vector_to_pdu_0</sink_block_id><source_key>pdu_out</source_key><sink_key>Vector_IN</sink_key></connection>
<connection><source_block_id>uaslink_binary_vector_to_pdu_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>Binary_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uaslink_pdu_to_binary_vector_1</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>uaslink_pdu_to_binary_vector_1</source_block_id><sink_block_id>no_delay_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_pdu_to_binary_vector_1</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
</flow_graph>
