<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radio_top_rpi</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfg</value></param>
<param><key>comment</key><value>A place to put values for various configurations.
Maybe better to use file variables.</value></param>
<param><key>value</key><value>{"base":{"freqs":[freqs[0],freqs[1]]},"remote":{"freqs":[freqs[1],freqs[0]]} }[config]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>[2.405e9,2.35e9]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>channel_loopback</key>
<param><key>id</key><value>channel_loopback_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>channel_tagged_uhd</key>
<param><key>id</key><value>channel_tagged_uhd_0</value></param>
<param><key>rx_freq</key><value>cfg["freqs"][0]</value></param>
<param><key>rx_gain</key><value>60</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>cfg["freqs"][1]</value></param>
<param><key>tx_gain</key><value>30</value></param>
</block>
<block>
<key>channel_uhd</key>
<param><key>id</key><value>channel_uhd_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>rx_freq</key><value>cfg["freqs"][0]</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>cfg["freqs"][1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>base</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>modem_iface</key>
<param><key>id</key><value>modem_iface_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>no_delay</key>
<param><key>id</key><value>no_delay_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_sink_pp</key>
<param><key>id</key><value>uaslink_pymavlink_source_sink_pp_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value></value></param>
</block>
<connection><source_block_id>channel_loopback_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_tagged_uhd_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_uhd_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>uaslink_pymavlink_source_sink_pp_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_loopback_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_tagged_uhd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_uhd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>data_tx_pdu</sink_key></connection>
</flow_graph>
