<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radio_top_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>200e3</value></param>
<param><key>label</key><value>bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10e3</value></param>
<param><key>stop</key><value>5e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>300e3</value></param>
<param><key>label</key><value>lo_offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-6e6</value></param>
<param><key>step</key><value>10e3</value></param>
<param><key>stop</key><value>6e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>3.013e9</value></param>
<param><key>label</key><value>rx_freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>60</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>3.017e9</value></param>
<param><key>label</key><value>tx_freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>70</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>channel_loopback</key>
<param><key>id</key><value>channel_loopback_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>channel_tagged_uhd_gui</key>
<param><key>id</key><value>channel_tagged_uhd_gui_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>rx_freq</key><value>rx_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>tx_freq</value></param>
</block>
<block>
<key>channel_uhd_gui</key>
<param><key>id</key><value>channel_uhd_gui_0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>bandwidth</key><value>bandwidth</value></param>
<param><key>lo_offset</key><value>lo_offset</value></param>
<param><key>rx_freq</key><value>rx_freq</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>200e3</value></param>
<param><key>tx_freq</key><value>tx_freq</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>import</key><value>import pyqt</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>lo_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>300e3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main_tab</value></param>
<param><key>label0</key><value>Main</value></param>
<param><key>label1</key><value>Chan</value></param>
<param><key>label2</key><value>Modem</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>modem_iface_gui</key>
<param><key>id</key><value>modem_iface_gui_0</value></param>
<param><key>gui_hint</key><value>main_tab@2</value></param>
<param><key>samp_rate</key><value>100e3</value></param>
</block>
<block>
<key>no_delay</key>
<param><key>id</key><value>no_delay_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>rx_freq</value></param>
<param><key>value</key><value>3.013e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>tx_freq</value></param>
<param><key>value</key><value>3.017e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>uaslink_binary_vector_to_pdu</key>
<param><key>id</key><value>uaslink_binary_vector_to_pdu_0</value></param>
</block>
<block>
<key>uaslink_mavlink_control</key>
<param><key>id</key><value>uaslink_mavlink_control_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'127.0.0.1:14560'</value></param>
</block>
<block>
<key>uaslink_message_debug_hex</key>
<param><key>id</key><value>uaslink_message_debug_hex_0</value></param>
<param><key>description</key><value>In Payload</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uaslink_message_debug_hex</key>
<param><key>id</key><value>uaslink_message_debug_hex_0_0</value></param>
<param><key>description</key><value>Out Payload</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uaslink_pdu_to_binary_vector</key>
<param><key>id</key><value>uaslink_pdu_to_binary_vector_1</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14001'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:6128'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:5056'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:6129'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:5057'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_1</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>channel_loopback_0</source_block_id><sink_block_id>modem_iface_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_tagged_uhd_gui_0</source_block_id><sink_block_id>modem_iface_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_uhd_gui_0</source_block_id><sink_block_id>modem_iface_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_gui_0</source_block_id><sink_block_id>uaslink_binary_vector_to_pdu_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>Vector_IN</sink_key></connection>
<connection><source_block_id>modem_iface_gui_0</source_block_id><sink_block_id>channel_loopback_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_gui_0</source_block_id><sink_block_id>channel_tagged_uhd_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_gui_0</source_block_id><sink_block_id>channel_uhd_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>no_delay_0</source_block_id><sink_block_id>uaslink_binary_vector_to_pdu_0</sink_block_id><source_key>pdu_out</source_key><sink_key>Vector_IN</sink_key></connection>
<connection><source_block_id>uaslink_binary_vector_to_pdu_0</source_block_id><sink_block_id>uaslink_message_debug_hex_0_0</sink_block_id><source_key>Binary_OUT</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>uaslink_binary_vector_to_pdu_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>Binary_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uaslink_binary_vector_to_pdu_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>Binary_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uaslink_mavlink_control_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uaslink_pdu_to_binary_vector_1</source_block_id><sink_block_id>modem_iface_gui_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>uaslink_pdu_to_binary_vector_1</source_block_id><sink_block_id>no_delay_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_message_debug_hex_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_pdu_to_binary_vector_1</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>uaslink_pdu_to_binary_vector_1</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_0</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>out</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_1</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>out</source_key><sink_key>Command</sink_key></connection>
</flow_graph>
