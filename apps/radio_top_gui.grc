<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radio_top_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfg</value></param>
<param><key>comment</key><value>A place to put values for various configurations.
Maybe better to use file variables.</value></param>
<param><key>value</key><value>{"base":{"freqs":[freqs[0],freqs[1]]},"remote":{"freqs":[freqs[1],freqs[0]]} }[config]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>[2.405e9,2.35e9]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/modem_xmit.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>256</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>channel_loopback</key>
<param><key>id</key><value>channel_loopback_0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>channel_uhd</key>
<param><key>id</key><value>channel_uhd_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1</value></param>
<param><key>rx_freq</key><value>cfg["freqs"][0]</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx_freq</key><value>cfg["freqs"][1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>base</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>import</key><value>import pyqt</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main_tab</value></param>
<param><key>label0</key><value>Main</value></param>
<param><key>label1</key><value>Chan</value></param>
<param><key>label2</key><value>Modem</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>modem_iface</key>
<param><key>id</key><value>modem_iface_0</value></param>
<param><key>gui_hint</key><value>main_tab@2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uaslink_pdu_control_to_pdu_vector</key>
<param><key>id</key><value>uaslink_pdu_control_to_pdu_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>pdus</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>channel_loopback_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_uhd_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_loopback_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modem_iface_0</source_block_id><sink_block_id>channel_uhd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uaslink_pdu_control_to_pdu_vector_0</source_block_id><sink_block_id>modem_iface_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_pdu_control_to_pdu_vector_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
</flow_graph>
