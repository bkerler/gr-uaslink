<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_modem_gui</value></param>
<param><key>category</key><value>[uaslink]</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from PyQt4 import Qt</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>modem_tab</value></param>
<param><key>label0</key><value>Tx</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pdu_in_port</value></param>
<param><key>label</key><value>pdu_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>psk_burst_rx_wrapper_gui</key>
<param><key>id</key><value>psk_burst_rx_wrapper_gui_0</value></param>
<param><key>gui_hint</key><value>modem_tab@1</value></param>
<param><key>pre_bits</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>psk_burst_tx_wrapper_gui</key>
<param><key>id</key><value>psk_burst_tx_wrapper_gui_0</value></param>
<param><key>gui_hint</key><value>modem_tab@0</value></param>
<param><key>pre_bits</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pud_out_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>pdu_out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>samples_in_port</value></param>
<param><key>label</key><value>samples_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>samples_out_port</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>samples_out</value></param>
</block>
<connection><source_block_id>pdu_in_port</source_block_id><sink_block_id>psk_burst_tx_wrapper_gui_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>psk_burst_rx_wrapper_gui_0</source_block_id><sink_block_id>pud_out_port</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>psk_burst_tx_wrapper_gui_0</source_block_id><sink_block_id>samples_out_port</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>samples_in_port</source_block_id><sink_block_id>psk_burst_rx_wrapper_gui_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
