<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tdma_modem</value></param>
<param><key>category</key><value>[uaslink]</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_slot</value></param>
<param><key>value</key><value>1250</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>data_rx_pdu_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>data_rx_pdu</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>data_tx_pdu_port</value></param>
<param><key>label</key><value>data_tx_pdu</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>demod_fb_block</key>
<param><key>id</key><value>demod_fb_block_0</value></param>
<param><key>samp_rate</key><value>100e3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from PyQt4 import Qt</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>link_ctrl_in_port</value></param>
<param><key>label</key><value>link_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>link_ctrl_out_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>link_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>mod_fb_block</key>
<param><key>id</key><value>mod_fb_block_0</value></param>
<param><key>samp_rate</key><value>100e3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>radio_ctrl_in_port</value></param>
<param><key>label</key><value>radio_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>radio_ctrl_out_port</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>radio_ctrl</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rx_samples_port</value></param>
<param><key>label</key><value>rx_samples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>tdma_stream_to_timeslot_pdu_c</key>
<param><key>id</key><value>tdma_stream_to_timeslot_pdu_c_0</value></param>
<param><key>num_deadtime_samples</key><value>0</value></param>
<param><key>samples_per_slot</key><value>samp_per_slot</value></param>
</block>
<block>
<key>tdma_uaslink_tdma_modem</key>
<param><key>id</key><value>tdma_uaslink_tdma_modem_0</value></param>
<param><key>sps</key><value>samp_per_slot</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>tx_samples_port</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>tx_samples</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>tx_samples_port</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>data_tx_pdu_port</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>out</source_key><sink_key>data_tx_pdu</sink_key></connection>
<connection><source_block_id>demod_fb_block_0</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>pdu</source_key><sink_key>demod_fb</sink_key></connection>
<connection><source_block_id>link_ctrl_in_port</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>out</source_key><sink_key>link_ctrl</sink_key></connection>
<connection><source_block_id>mod_fb_block_0</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>pdu</source_key><sink_key>mod_fb</sink_key></connection>
<connection><source_block_id>radio_ctrl_in_port</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>out</source_key><sink_key>radio_ctrl</sink_key></connection>
<connection><source_block_id>rx_samples_port</source_block_id><sink_block_id>tdma_stream_to_timeslot_pdu_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdma_stream_to_timeslot_pdu_c_0</source_block_id><sink_block_id>tdma_uaslink_tdma_modem_0</sink_block_id><source_key>pdu</source_key><sink_key>rx_pdu</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>data_rx_pdu_port</sink_block_id><source_key>data_rx_pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>demod_fb_block_0</sink_block_id><source_key>demod_fb</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>link_ctrl_out_port</sink_block_id><source_key>link_ctrl</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>mod_fb_block_0</sink_block_id><source_key>mod_fb</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>radio_ctrl_out_port</sink_block_id><source_key>radio_ctrl</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>tdma_stream_to_timeslot_pdu_c_0</sink_block_id><source_key>rx_tdma_ctrl</source_key><sink_key>ctrl_pdu</sink_key></connection>
<connection><source_block_id>tdma_uaslink_tdma_modem_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>tx_pdu</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
