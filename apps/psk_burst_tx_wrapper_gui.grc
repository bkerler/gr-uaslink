<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_tx_wrapper_gui</value></param>
<param><key>category</key><value>[uaslink]</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
</block>
<block>
<key>burst_framer</key>
<param><key>id</key><value>burst_framer_0</value></param>
<param><key>bs</key><value>2400</value></param>
</block>
<block>
<key>burst_preamble_insert</key>
<param><key>id</key><value>burst_preamble_insert_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_scheduler</key>
<param><key>id</key><value>burst_scheduler_0</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from PyQt4 import Qt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>import</key><value>import pyqt</value></param>
</block>
<block>
<key>mapper_mapper_msg</key>
<param><key>id</key><value>mapper_mapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>msg_burst_out_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>samples_out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>msg_pdu_in_src</value></param>
<param><key>label</key><value>pdu_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>2.0</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<connection><source_block_id>burst_framer_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>unpacked_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_preamble_insert_0</source_block_id><sink_block_id>mapper_mapper_msg_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_randomizer_0</source_block_id><sink_block_id>burst_preamble_insert_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>nproduced</source_key><sink_key>nproduced</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>cpdus</source_key><sink_key>sched_pdu</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>msg_pdu_in_src</source_block_id><sink_block_id>burst_framer_0</sink_block_id><source_key>out</source_key><sink_key>packed_pdus</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>msg_burst_out_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
